# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x080000) IROM(0x08000000,0x780000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1
  c define: __RTTHREAD__, RT_USING_LIBC, USE_STDPERIPH_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, GD32F527, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC
  c include: ..\..\..\..\components\dfs\dfs_v1\include;packages\gd32-arm-cmsis-latest\GD32F5xx;packages\gd32-arm-cmsis-latest\GD32F5xx\GD\GD32F5xx\Include;..\..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\..\components\net\sal\include\socket;..\..\..\..\components\drivers\spi;..\..\..\..\components\drivers\include;..\libraries\gd32_drivers;..\..\..\..\components\finsh;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\net\sal\include\dfs_net;..\..\..\..\components\net\netdev\include;..\..\..\..\components\drivers\wlan;..\..\..\..\components\drivers\include;.;..\..\..\..\libcpu\arm\cortex-m33;packages\rw007-v2.1.0\inc;packages\gd32-arm-series-latest\GD32F5xx\GD32F5xx_standard_peripheral\Include;applications;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\phy;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\include;..\..\..\..\components\net\sal\impl;..\..\..\..\libcpu\arm\common;..\..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\..\components\libc\posix\ipc;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;board;..\..\..\..\components\net\lwip\port;..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;packages\rw007-v2.1.0;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\..\..\components\net\sal\include;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../../components/drivers/wlan/: dev_wlan.c dev_wlan_cfg.c dev_wlan_cmd.c dev_wlan_lwip.c dev_wlan_mgnt.c dev_wlan_prot.c dev_wlan_workqueue.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_pwm.c drv_spi.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/src/: dfs_posix.c dfs_file.c dfs.c dfs_fs.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c msh.c shell.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kstdio.c rt_vsnprintf_tiny.c kerrno.c kstring.c rt_vsscanf.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F5xx/GD/GD32F5xx/Source/ARM/: startup_gd32f5xx.s
    packages/gd32-arm-cmsis-latest/GD32F5xx/GD/GD32F5xx/Source/: system_gd32f5xx.c
    packages/gd32-arm-series-latest/GD32F5xx/GD32F5xx_standard_peripheral/Source/: gd32f5xx_dma.c gd32f5xx_exti.c gd32f5xx_gpio.c gd32f5xx_misc.c gd32f5xx_rcu.c gd32f5xx_spi.c gd32f5xx_syscfg.c gd32f5xx_timer.c gd32f5xx_usart.c
  group lwIP
    ../../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
    packages/rw007-v2.1.0/example/: rw007_stm32_port.c
  group SAL
    ../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../../components/net/sal/src/: sal_socket.c
software components: CMSIS:CORE 5.6.0
